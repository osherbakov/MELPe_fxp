# Keil uVision project Melpe.uvprojx, settings and files
target MELPE (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: Melpe +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: __DBG_ITM
  c include: C:\Keil5.0\ARM\RV31\INC;..\..\..\melpe_fxp_src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Codec
    ../../: classify.c coeff.c dsp_sub.c fec_code.c fft_lib.c fs_lib.c fsvq_cb.c global.c harm.c lpc_lib.c mat_lib.c math_lib.c mathdp31.c melp_ana.c melp_chn.c melp_sub.c melp_syn.c msvq_cb.c npp.c pit_lib.c pitch.c postfilt.c qnt12.c qnt12_cb.c sc1200.c transcode.c vq_lib.c
    ../../ARM/: mathhalf.c
  group System
    ../../ARM/: Retarget.c Serial.c
  group ::CMSIS
    C:/Keil5.0/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/STM32F401RE/: RTE_Device.h startup_stm32f401xx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, Device:Startup 1.3.0
